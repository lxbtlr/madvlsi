** sch_path: miniproject2/MP1_and.sch
**.subckt MP1_and A B Out
*.ipin A
*.ipin B
*.opin Out
x1 A net1 B MP1_nand
x2 Out net1 MP1_inverter
**.ends
.end
