** sch_path: miniproject2/MP1.sch
**.subckt MP1 A VCC Out
*.ipin A
*.ipin VCC
*.opin Out
M2 Out A VCC DMP2035U m=1
M1 Out A GND M2N7002 m=1
**.ends
.GLOBAL GND
.end
